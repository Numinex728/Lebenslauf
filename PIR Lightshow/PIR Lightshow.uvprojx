# Keil uVision project PIR Lightshow.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PIR Lightshow
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: interrupt.c interrupt.h main.c warten.c warten.h pir.c pir.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
